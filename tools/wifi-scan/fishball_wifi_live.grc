options:
  parameters:
    author: Matthieu
    comment: |-
      Live Wi-Fi channel analyser for the Fishball7020.

      Five measurements from one receive stream, plus a sweep controller that
      lives inside the flowgraph as a Python Snippet - so this DOES sweep, it
      just cannot draw the sweeping as wires.

        spectrum + waterfall   what is on the air, both receivers
        channel power          the selected 20 MHz channel alone, in dBFS
        busy  percentage of captured time over the threshold
        burst envelope         individual packets, in the time domain
        RX1-RX2 phase          the two coherent receivers against each other

      The radio is NOT tuned to the channel centre. It sits 15 MHz below it, so
      the AD9361's own LO leak lands clear of the traffic; every display is
      corrected back, so the x-axis reads true frequency and the spike 15 MHz
      below the channel is the receiver looking at itself.
    description: Live 2.4/5 GHz Wi-Fi channel analyser for the Fishball7020
    generate_options: qt_gui
    id: fishball_wifi_live
    output_language: python
    title: Fishball7020 - live Wi-Fi channel analyser
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 'The AD9361''s maximum. Wide enough that a whole 20 MHz channel fits clear of DC once the LO is offset - which a narrower rate cannot do. The cost: 61.44 MSPS is 245 MB/s and this link carries about 31, so the stream arrives in bursts. Spectra are unaffected (every transform sees contiguous samples); the busy percentage is over CAPTURED time.'
    value: '61440000'
  states: {bus_structure: 'null'}
- name: nfft
  id: variable
  parameters:
    comment: 15.0 kHz resolution at 61.44 MSPS.
    value: '4096'
  states: {bus_structure: 'null'}
- name: uri
  id: variable
  parameters:
    comment: Found by name, so DHCP may move the board.
    value: '''ip:fishball.local'''
  states: {bus_structure: 'null'}
- name: lo_offset
  id: variable
  parameters:
    comment: Offset tuning. The LO leak and the converters' DC offset land at the centre of whatever the radio is tuned to, so do not tune to the thing you want to measure.
    value: '-15000000'
  states: {bus_structure: 'null'}
- name: chan_bw
  id: variable
  parameters:
    comment: One 802.11 channel.
    value: '20000000'
  states: {bus_structure: 'null'}
- name: chan_decim
  id: variable
  parameters:
    comment: 61.44 -> 30.72 MSPS, still comfortably over one 20 MHz channel.
    value: '2'
  states: {bus_structure: 'null'}
- name: chan_taps
  id: variable
  parameters:
    comment: The channel-selecting filter. 3 MHz of transition either side, which is cheap here because the xlating FFT filter convolves in the frequency domain rather than tap by tap.
    value: firdes.low_pass(1.0, samp_rate, chan_bw/2, 3000000)
  states: {bus_structure: 'null'}
- name: sweep_list
  id: variable
  parameters:
    comment: What the sweep walks through, when it is switched on.
    value: '[2412000000, 2437000000, 2462000000, 5180000000, 5200000000, 5220000000, 5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5540000000, 5745000000]'
  states: {bus_structure: 'null'}
- name: chan
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,2
    label: Wi-Fi channel
    labels: '[''2.4 GHz  ch 1  - 2412'', ''2.4 GHz  ch 6  - 2437'', ''2.4 GHz  ch 11 - 2462'', ''5 GHz  ch 36 - 5180'', ''5 GHz  ch 40 - 5200'', ''5 GHz  ch 44 - 5220'', ''5 GHz  ch 48 - 5240'', ''5 GHz  ch 52 - 5260'', ''5 GHz  ch 56 - 5280'', ''5 GHz  ch 60 - 5300'', ''5 GHz  ch 64 - 5320'', ''5 GHz  ch 100 - 5500'', ''5 GHz  ch 108 - 5540'', ''5 GHz  ch 149 - 5745'']'
    num_opts: '0'
    options: '[2412000000, 2437000000, 2462000000, 5180000000, 5200000000, 5220000000, 5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5540000000, 5745000000]'
    type: int
    value: '5320000000'
    widget: combo
  states: {bus_structure: 'null'}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: 'Manual, never AGC: automatic gain moves the reference level under you and nothing on screen means anything absolute afterwards. The chip swaps gain tables at 4 GHz - 71 dB is the ceiling below it, 62 above, and a value out of range is refused with nothing but a log line.'
    gui_hint: 0,2,1,2
    label: RX gain (dB)  -  max 71 below 4 GHz, 62 above
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '62'
    value: '55'
  states: {bus_structure: 'null'}
- name: busy_thresh
  id: variable_qtgui_range
  parameters:
    comment: Above this, the channel counts as occupied. Read the channel power reading with nothing transmitting and set this a few dB over it.
    gui_hint: 0,4,1,2
    label: Busy threshold (dBFS)
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-55'
  states: {bus_structure: 'null'}
- name: sweep_on
  id: variable_qtgui_check_box
  parameters:
    comment: Read by the Python Snippet below, which steps the chooser through sweep_list. A flowgraph cannot draw a sweep as wires - but it can carry the controller that does it.
    'false': '0'
    gui_hint: 1,0,1,2
    label: Sweep the channel list (1 s per channel)
    type: int
    'true': '1'
    value: '0'
  states: {bus_structure: 'null'}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '52000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: BOTH receivers. They share one local oscillator, which is what makes the phase measurement below mean anything. Quadrature tracking keeps a strong signal from putting a mirror image of itself on the other side of the centre; the two DC loops keep the LO leak from growing.
    filter_source: '''Off'''
    frequency: int(chan + lo_offset)
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: gain
    manual_gain2: gain
    rf_port_select: '''A_BALANCED'''
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {bus_structure: 'null'}
- name: chan_filter
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: '-lo_offset'
    comment: Selects the chosen channel out of the 56 MHz window and brings it to baseband. center_freq is +15 MHz because the radio was tuned 15 MHz low - this undoes the offset tuning, so everything downstream sees the channel and nothing else, including none of the LO leak.
    decim: chan_decim
    samp_rate: samp_rate
    taps: chan_taps
  states: {bus_structure: 'null'}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: Power per sample. gr-iio scales full scale to 1.0, so 1.0 here is 0 dBFS.
  states: {bus_structure: 'null'}
- name: pwr_smooth
  id: blocks_moving_average_xx
  parameters:
    comment: '67 us of smoothing: long enough to settle the estimate, short enough that a Wi-Fi packet still looks like a packet rather than a smear.'
    length: '2048'
    max_iter: '4096'
    scale: 1.0/2048
    type: float
  states: {bus_structure: 'null'}
- name: pwr_decim
  id: blocks_keep_one_in_n
  parameters:
    comment: 30.72 MSPS is far more than a meter needs. Down to about 30 kHz.
    n: '1024'
    type: float
  states: {bus_structure: 'null'}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: 10*log10 - power, so 10 and not 20.
    k: '0'
    n: '10'
  states: {bus_structure: 'null'}
- name: qtgui_number_sink_pwr
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    color1: ("black", "red")
    comment: The selected channel alone, with the LO leak filtered out of it.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,2,1,2
    label1: channel power
    max: '0'
    min: '-100'
    name: '"Channel power (dBFS)"'
    type: float
    unit1: dBFS
  states: {bus_structure: 'null'}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    comment: 1 while the channel is over the threshold, 0 under it. The 2 dB gap between the two levels is hysteresis, so a signal sitting exactly on the threshold does not chatter.
    high: busy_thresh+1
    init: '0'
    low: busy_thresh-1
  states: {bus_structure: 'null'}
- name: busy_smooth
  id: blocks_moving_average_xx
  parameters:
    comment: The mean of a 0/1 signal IS the duty cycle. About a second of it at this rate.
    length: '30000'
    max_iter: '60000'
    scale: 100.0/30000
    type: float
  states: {bus_structure: 'null'}
- name: qtgui_number_sink_busy
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    color1: ("black", "red")
    comment: Percentage of CAPTURED time, not of wall-clock time - at 61.44 MSPS this link delivers roughly an eighth of the samples. It is a fair sample of the channel's state, not a census of it.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,4,1,2
    label1: busy
    max: '100'
    min: '0'
    name: '"Channel busy (% of captured time)"'
    type: float
    unit1: '%'
  states: {bus_structure: 'null'}
- name: env_decim
  id: blocks_keep_one_in_n
  parameters:
    comment: 480 kSPS, so 1024 points on the time sink is about 2 ms - the scale on which a Wi-Fi packet is visible as a packet.
    n: '64'
    type: complex
  states: {bus_structure: 'null'}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {bus_structure: 'null'}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Individual packets. Set the trigger to Normal on channel 0 with a level just above the noise and a burst will hold still on screen.
    grid: 'True'
    gui_hint: 10,0,3,6
    label1: envelope
    name: '"Burst envelope - individual packets"'
    size: '1024'
    srate: samp_rate/chan_decim/64
    type: float
    width1: '2'
    ylabel: magnitude
    ymin: '0'
  states: {bus_structure: 'null'}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters:
    comment: RX1 x conj(RX2). The angle of the result is the phase difference between the two antennas - the quantity a direction finder works from. Both receivers share one LO, so this is stable rather than drifting.
  states: {bus_structure: 'null'}
- name: phase_smooth
  id: blocks_moving_average_xx
  parameters:
    comment: Averaged as a COMPLEX number, before taking the angle. Averaging angles is wrong - they wrap, and the mean of +179 and -179 degrees is not zero.
    length: '8192'
    max_iter: '16384'
    scale: 1.0/8192
    type: complex
  states: {bus_structure: 'null'}
- name: phase_decim
  id: blocks_keep_one_in_n
  parameters:
    n: '4096'
    type: complex
  states: {bus_structure: 'null'}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {bus_structure: 'null'}
- name: rad_to_deg
  id: blocks_multiply_const_vxx
  parameters:
    const: '57.29577951308232'
    type: float
  states: {bus_structure: 'null'}
- name: qtgui_number_sink_phase
  id: qtgui_number_sink
  parameters:
    avg: '0.0'
    color1: ("black", "red")
    comment: NOT calibrated. Each port has its own fixed offset through its own balun and traces, so this is a repeatable number rather than a bearing. Measure the offset with a splitter and matched cables before trusting any angle - and note it changes with frequency.
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 2,0,1,6
    label1: RX1 - RX2 phase (uncalibrated)
    max: '180'
    min: '-180'
    name: '"RX1 - RX2 phase, degrees (uncalibrated)"'
    type: float
    unit1: deg
  states: {bus_structure: 'null'}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: 'Both receivers. Turn on Max Hold in the control panel: Wi-Fi is silent between bursts, and the average alone will tell you an occupied channel is empty.'
    ctrlpanel: 'True'
    fc: int(chan + lo_offset)
    fftsize: nfft
    grid: 'True'
    gui_hint: 3,0,4,6
    label1: RX1
    label2: RX2
    name: '"Spectrum - the channel sits 15 MHz above the DC spike"'
    nconnections: '2'
    type: complex
    ymax: '0'
    ymin: '-110'
  states: {bus_structure: 'null'}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Time runs downwards. This is where burstiness becomes obvious - a beacon every 100 ms is a dashed line, a busy channel is solid.
    fc: int(chan + lo_offset)
    fftsize: nfft
    gui_hint: 7,0,3,6
    int_max: '-20'
    int_min: '-110'
    label: Relative Gain
    label1: RX1
    name: '"Waterfall - bursts over time"'
    type: complex
  states: {bus_structure: 'null'}
- name: sweep_controller
  id: snippet
  parameters:
    code: |-
      import threading, time

      def _sweep(tb):
          # A flowgraph cannot draw a sweep as wires, but it can carry the thread
          # that drives one. Setting the chooser variable is exactly what clicking
            # it does: GRC's generated set_chan() retunes the source and moves the
          # centre frequency of every display with it.
          while True:
              if getattr(tb, 'sweep_on', 0):
                  for f in tb.sweep_list:
                      if not getattr(tb, 'sweep_on', 0):
                          break
                      tb.set_chan(f)
                      time.sleep(1.0)
              else:
                  time.sleep(0.2)

      threading.Thread(target=_sweep, args=(self,), daemon=True).start()
    section: main_after_start
  states: {bus_structure: 'null'}

connections:
- [iio_fmcomms2_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_fmcomms2_source_0, '1', qtgui_freq_sink_x_0, '1']
- [iio_fmcomms2_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [iio_fmcomms2_source_0, '0', chan_filter, '0']
- [iio_fmcomms2_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [iio_fmcomms2_source_0, '1', blocks_multiply_conjugate_cc_0, '1']
- [chan_filter, '0', blocks_complex_to_mag_squared_0, '0']
- [chan_filter, '0', env_decim, '0']
- [blocks_complex_to_mag_squared_0, '0', pwr_smooth, '0']
- [pwr_smooth, '0', pwr_decim, '0']
- [pwr_decim, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_pwr, '0']
- [blocks_nlog10_ff_0, '0', blocks_threshold_ff_0, '0']
- [blocks_threshold_ff_0, '0', busy_smooth, '0']
- [busy_smooth, '0', qtgui_number_sink_busy, '0']
- [env_decim, '0', blocks_complex_to_mag_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', phase_smooth, '0']
- [phase_smooth, '0', phase_decim, '0']
- [phase_decim, '0', blocks_complex_to_arg_0, '0']
- [blocks_complex_to_arg_0, '0', rad_to_deg, '0']
- [rad_to_deg, '0', qtgui_number_sink_phase, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
