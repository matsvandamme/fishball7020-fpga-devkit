options:
  parameters:
    author: Matthieu
    comment: |-
      Live Wi-Fi band viewer for the Fishball7020.

      The sweeping scanner next door (wifi_scan.py) cannot be drawn as a plain
      flowgraph, because a sweep needs a controller that retunes between dwells.
      This is the other half: point it at one channel and watch it in real time.

      Pick a channel from the chooser. The radio is NOT tuned to the channel
      centre - it is tuned 15 MHz below it, so the AD9361's own LO leak lands
      well clear of the traffic. The display is corrected back, so what you read
      off the x-axis is the true frequency; the spike 15 MHz below the channel is
      the receiver looking at itself.
    description: Live 2.4/5 GHz Wi-Fi viewer for the Fishball7020
    generate_options: qt_gui
    id: fishball_wifi_live
    output_language: python
    title: Fishball7020 - live Wi-Fi band viewer
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: 'The AD9361''s maximum: 56 MHz of usable window, so about three 20 MHz channels at once.'
    value: '61440000'
  states: {}
- name: nfft
  id: variable
  parameters:
    comment: 15.0 kHz resolution at 61.44 MSPS.
    value: '4096'
  states: {}
- name: uri
  id: variable
  parameters:
    comment: Found by name, so DHCP may move the board.
    value: '''ip:fishball.local'''
  states: {}
- name: lo_offset
  id: variable
  parameters:
    comment: Offset tuning. The LO leak and the converters' DC offset land at the centre of whatever the radio is tuned to, so do not tune to the thing you want to measure. 15 MHz puts the artefact outside the channel while keeping the channel inside the 56 MHz window.
    value: '-15000000'
  states: {}
- name: chan
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Wi-Fi channel
    labels: '[''2.4 GHz  ch 1  - 2412 MHz'', ''2.4 GHz  ch 6  - 2437 MHz'', ''2.4 GHz  ch 11 - 2462 MHz'', ''5 GHz  ch 36 - 5180 MHz'', ''5 GHz  ch 40 - 5200 MHz'', ''5 GHz  ch 44 - 5220 MHz'', ''5 GHz  ch 48 - 5240 MHz'', ''5 GHz  ch 52 - 5260 MHz'', ''5 GHz  ch 56 - 5280 MHz'', ''5 GHz  ch 60 - 5300 MHz'', ''5 GHz  ch 64 - 5320 MHz'', ''5 GHz  ch 100 - 5500 MHz'', ''5 GHz  ch 108 - 5540 MHz'', ''5 GHz  ch 149 - 5745 MHz'']'
    num_opts: '0'
    options: '[2412000000, 2437000000, 2462000000, 5180000000, 5200000000, 5220000000, 5240000000, 5260000000, 5280000000, 5300000000, 5320000000, 5500000000, 5540000000, 5745000000]'
    type: int
    value: '5320000000'
    widget: combo
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: 'Manual, never AGC: automatic gain moves the reference level under you and nothing on screen means anything absolute afterwards. NOTE the chip swaps gain tables at 4 GHz - the maximum is 71 dB below it and only 62 dB above, and a value out of range is refused with nothing but a log line.'
    gui_hint: 1,0,1,1
    label: RX gain (dB)   -   max is 71 below 4 GHz, 62 above
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '62'
    value: '55'
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '52000000'
    bbdc: 'True'
    buffer_size: '32768'
    comment: RX1 only. Quadrature tracking keeps a strong signal from putting a mirror image of itself on the other side of the centre; the two DC loops keep the LO leak from growing.
    filter_source: '''Off'''
    frequency: int(chan + lo_offset)
    gain1: '''manual'''
    manual_gain1: gain
    rf_port_select: '''A_BALANCED'''
    rx1_en: 'True'
    rx2_en: 'False'
    samplerate: samp_rate
    type: fc32
    uri: uri
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    comment: 'Turn on Max Hold in the control panel (right-click, or the Control Panel checkbox): Wi-Fi is silent between bursts, and the average alone will tell you an occupied channel is empty.'
    ctrlpanel: 'True'
    fc: int(chan + lo_offset)
    fftsize: nfft
    grid: 'True'
    gui_hint: 2,0,4,1
    label1: RX1
    name: '"Spectrum - the channel sits 15 MHz above the DC spike"'
    type: complex
    ymax: '0'
    ymin: '-110'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    comment: Time runs downwards. This is where Wi-Fi's burstiness becomes obvious - a beacon every 100 ms is a dashed line, a busy channel is solid.
    fc: int(chan + lo_offset)
    fftsize: nfft
    gui_hint: 6,0,4,1
    int_max: '-20'
    int_min: '-110'
    label: Relative Gain
    label1: RX1
    name: '"Waterfall - bursts over time"'
    type: complex
  states: {}

connections:
- [iio_fmcomms2_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_fmcomms2_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
