options:
  parameters:
    author: Matthieu
    comment: |-
      Two coherent receivers

      RX1 and RX2 share one oscillator and one clock, so
      the phase between them means something. Nothing
      else in this repository shows it.

      READ COHERENCE BEFORE THE ANGLE. Near 1 the angle
      is a measurement; near 0 it is noise wearing the
      same clothes. The dial's radius IS the coherence.

      Repeatable is not calibrated. Receive only.
    description: RX1/RX2 phase and coherence from one shared oscillator
    generate_options: qt_gui
    id: fishball_coherent_rx
    output_language: python
    title: Fishball7020 - two coherent receivers
  states: {}

blocks:
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: uri
  id: variable
  parameters:
    value: '''ip:fishball.local'''
  states: {}
- name: buf
  id: variable
  parameters:
    value: '262144'
  states: {}
- name: chunk
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: center_hz
  id: variable
  parameters:
    value: int(center_mhz * 1e6)
  states: {}
- name: lo_off_hz
  id: variable
  parameters:
    value: lo_frac * samp_rate
  states: {}
- name: sel_taps
  id: variable
  parameters:
    value: firdes.low_pass(1.0, samp_rate, sel_bw_khz * 500.0, sel_bw_khz * 200.0)
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: '''Sample rate'''
    type: real
    num_opts: '3'
    options: '[2560000, 5000000, 10000000]'
    labels: '[''2.56 MS/s  (20 MB/s, 2ch)'', ''5 MS/s  (40 MB/s, 2ch)'', ''10 MS/s  (80 MB/s, 2ch)'']'
    value: '5000000'
    gui_hint: 0,0,1,2
    option0: '2560000'
    label0: '''2.56 MS/s  (20 MB/s, 2ch)'''
    option1: '5000000'
    label1: '''5 MS/s  (40 MB/s, 2ch)'''
    option2: '10000000'
    label2: '''10 MS/s  (80 MB/s, 2ch)'''
    comment: Two channels, so twice the bytes of one.
  states: {}
- name: center_mhz
  id: variable_qtgui_range
  parameters:
    label: '''Centre frequency (MHz)'''
    value: '2437'
    start: '70'
    stop: '6000'
    step: '0.5'
    orient: Qt.Horizontal
    gui_hint: 1,0,1,2
    comment: Where to look.
  states: {}
- name: lo_frac
  id: variable_qtgui_range
  parameters:
    label: '''LO offset (fraction of span)'''
    value: '0.25'
    start: '-0.4'
    stop: '0.4'
    step: '0.01'
    orient: Qt.Horizontal
    gui_hint: 2,0,1,2
    comment: |-
      Keeps the LO leak out of the correlation.
      Set it to 0 to see what that costs.
  states: {}
- name: sel_bw_khz
  id: variable_qtgui_range
  parameters:
    label: '''Band-select width (kHz)'''
    value: '400'
    start: '20'
    stop: '3000'
    step: '10'
    orient: Qt.Horizontal
    gui_hint: 3,0,1,2
    comment: |-
      Widen it past the LO offset and the leak
      gets in. Worth seeing once.
  states: {}
- name: rx1_gain
  id: variable_qtgui_range
  parameters:
    label: '''RX1 gain (dB)'''
    value: '40'
    start: '0'
    stop: '71'
    step: '1'
    orient: Qt.Horizontal
    gui_hint: 4,0,1,2
    comment: |-
      Separate on purpose: the two receivers
      differ by about 1.5 dB.
  states: {}
- name: rx2_gain
  id: variable_qtgui_range
  parameters:
    label: '''RX2 gain (dB)'''
    value: '40'
    start: '0'
    stop: '71'
    step: '1'
    orient: Qt.Horizontal
    gui_hint: 5,0,1,2
    comment: |-
      Unequal gains change amplitude but NOT
      phase. Prove it on the dial.
  states: {}
- name: avg
  id: variable_qtgui_range
  parameters:
    label: '''Averaging (estimates)'''
    value: '8'
    start: '1'
    stop: '200'
    step: '1'
    orient: Qt.Horizontal
    gui_hint: 6,0,1,2
    comment: Complex-domain average. Steadier, slower.
  states: {}
- name: zero
  id: variable_qtgui_check_box
  parameters:
    label: '''zero (latch this phase as the reference)'''
    type: bool
    value: 'False'
    'true': 'True'
    'false': 'False'
    gui_hint: 7,0,1,2
    comment: |-
      Latches on the RISING EDGE only, or it
      would re-zero forever.
  states: {}
- name: note_try
  id: note
  parameters:
    note: |-
      Three things to try, in order.

      1. WITH TWO ANTENNAS, find any steady carrier and watch coherence. Move one
         antenna a few centimetres and the angle moves; put it back and the angle
         comes back. That repeatability IS the coherent-receiver property.

      2. TICK `zero`, then move an antenna. The reading is now relative to where you
         zeroed. Untick it to see the raw angle again - the raw number is on its own
         readout precisely so that zeroing can never hide it.

      3. WIDEN `band-select` past the LO offset, so that DC falls inside the filter.
         Coherence will climb toward 1 and stay there, steady and convincing, and it
         will be measuring the receiver's own LO leak talking to itself. This is the
         failure this example is arranged to avoid, and it is worth seeing once so
         you recognise it elsewhere.

      The averaging control is a trade: more frames is a steadier angle and a slower
      response to a real change. At the default chunk of 4096 samples and 8 frames,
      the estimate settles in a few tenths of a second.
  states: {}
- name: rx
  id: iio_fmcomms2_source
  parameters:
    type: fc32
    uri: uri
    frequency: int(center_hz - lo_off_hz)
    samplerate: samp_rate
    buffer_size: buf
    rx1_en: 'True'
    rx2_en: 'True'
    quadrature: 'True'
    rfdc: 'True'
    bbdc: 'True'
    gain1: '''manual'''
    manual_gain1: rx1_gain
    gain2: '''manual'''
    manual_gain2: rx2_gain
    rf_port_select: '''A_BALANCED'''
    filter_source: '''Auto'''
    bandwidth: int(samp_rate)
    comment: |-
      BOTH receivers, one LO, one clock. That
      shared oscillator is the whole point.
  states: {}
- name: sel1
  id: freq_xlating_fft_filter_ccc
  parameters:
    decim: '1'
    taps: sel_taps
    center_freq: lo_off_hz
    samp_rate: samp_rate
    comment: |-
      Band-select RX1, which throws DC and the
      LO leak away with it.
  states: {}
- name: sel2
  id: freq_xlating_fft_filter_ccc
  parameters:
    decim: '1'
    taps: sel_taps
    center_freq: lo_off_hz
    samp_rate: samp_rate
    comment: |-
      IDENTICAL to sel1, so whatever phase it
      adds cancels out of the difference.
  states: {}
- name: phase
  id: epy_block
  parameters:
    chunk: chunk
    avg: avg
    zero: zero
    comment: |-
      Averages the correlation as a COMPLEX
      number, then takes the angle.
    _source_code: |
      """The phase between two receivers that share one oscillator.

      This is the measurement the Fishball7020 can make and a single-channel radio
      cannot. RX1 and RX2 sit in one AD9361 behind one LO and one sample clock, so
      the phase difference between them is a property of the signal and the cabling
      rather than of two drifting clocks. Nothing else in this repository shows it.

      AVERAGE THE CORRELATION, NEVER THE ANGLE. The estimate is

          r = mean( x1 * conj(x2) )

      and the phase is angle(r) taken AFTER the averaging. Averaging angles is
      wrong, and wrong in a way that looks fine: angles wrap at +/-180 degrees, so a
      true phase sitting near 180 has samples landing at +179 and -179 that average
      to about zero. A signal hard against the wrap point would read as no phase
      shift at all. Summing complex numbers has no wrap to fall foul of.

      COHERENCE IS WHY YOU CAN BELIEVE THE ANGLE.

          coherence = |mean(x1 conj(x2))| / sqrt( mean|x1|^2 * mean|x2|^2 )

      It runs from 0 to 1. Two independent noise streams give a correlation that
      random-walks toward zero as it averages, so their angle is a random number
      that still displays as confidently as a real one. Near 1 the two inputs are
      the same signal and the angle means something; near 0 you are reading noise.
      Watch this before believing anything on the dial.

      REPEATABLE IS NOT CALIBRATED. Each receive path has its own fixed delay
      through its own balun and its own trace, so there is a phase offset that has
      nothing to do with what is in the air. `zero` latches the current reading and
      subtracts it, which makes subsequent readings relative to that moment - useful
      and honest. It does NOT make the angle a direction of arrival. That needs a
      splitter, matched cables and a known geometry, and the offset changes with
      frequency, so a calibration at 2.4 GHz does not hold at 5 GHz. See
      docs/measured-performance.md.
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):
          """RX1/RX2 phase + coherence

            in  0  RX1        in  1  RX2
            out 0  phase difference, degrees, after the zero offset
            out 1  coherence, 0 to 1
            out 2  phase difference, degrees, raw
            out 3  coherence * exp(j * phase) - one point for a polar display

          Decimates by `chunk`: one estimate per chunk input samples, which is what
          a display can use and roughly a thousand times less work than one per
          sample. Port 3 is the neat one - feed it to a constellation sink and you
          have a dial whose ANGLE is the phase and whose RADIUS is how much you
          should trust it. A point pinned to the rim is a real measurement; one
          wandering near the origin is noise wearing the same clothes.
          """

          def __init__(self, chunk=4096, avg=8.0, zero=False):
              gr.decim_block.__init__(
                  self, name='RX1/RX2 phase + coherence',
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.float32, np.float32, np.float32, np.complex64],
                  decim=int(chunk))
              self._chunk = int(chunk)
              self._avg = max(1.0, float(avg))
              self._zero = bool(zero)
              self._r = None            # running complex correlation
              self._p = 0.0             # running mean power product
              self._offset = 0.0        # latched calibration, radians

          @property
          def avg(self):
              return self._avg

          @avg.setter
          def avg(self, v):
              self._avg = max(1.0, float(v))

          @property
          def zero(self):
              return self._zero

          @zero.setter
          def zero(self, v):
              v = bool(v)
              # Latch on the rising edge only. Holding the box ticked would keep
              # re-zeroing, and the reading would sit at zero no matter what the
              # antennas did - which is a convincing way to measure nothing.
              if v and not self._zero and self._r is not None:
                  self._offset = float(np.angle(self._r))
              self._zero = v
              if not v:
                  self._offset = 0.0

          def work(self, input_items, output_items):
              a, b = input_items[0], input_items[1]
              n = len(output_items[0])
              for i in range(n):
                  s = slice(i * self._chunk, (i + 1) * self._chunk)
                  x1, x2 = a[s], b[s]
                  r = np.vdot(x2, x1) / self._chunk        # mean(x1 * conj(x2))
                  p = float((np.abs(x1) ** 2).mean() * (np.abs(x2) ** 2).mean())

                  if self._r is None:
                      self._r, self._p = r, p
                  else:
                      self._r += (r - self._r) / self._avg
                      self._p += (p - self._p) / self._avg

                  coh = float(np.abs(self._r) / np.sqrt(self._p)) if self._p > 0 else 0.0
                  coh = min(coh, 1.0)
                  raw = float(np.angle(self._r))
                  # Wrap into +/-pi after subtracting the offset, so the display does
                  # not jump by 360 when a zeroed reading crosses the boundary.
                  cal = (raw - self._offset + np.pi) % (2 * np.pi) - np.pi

                  output_items[0][i] = np.degrees(cal)
                  output_items[1][i] = coh
                  output_items[2][i] = np.degrees(raw)
                  output_items[3][i] = coh * np.exp(1j * cal)
              return n
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: '''Both receivers, as tuned (centre = the LO)'''
    fftsize: '4096'
    fc: int(center_hz - lo_off_hz)
    bw: samp_rate
    grid: 'True'
    average: '0.2'
    ymin: '-130'
    ymax: '-10'
    label: '''level'''
    units: '''dBFS'''
    nconnections: '2'
    tr_tag: ''''''
    label1: '''RX1'''
    label2: '''RX2'''
    gui_hint: 0,2,5,10
    comment: |-
      UNfiltered, centred on the LO. The spike
      in the middle is the receiver itself.
  states: {}
- name: dial
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: '''Phase dial - angle is phase, radius is coherence'''
    size: '64'
    grid: 'True'
    ymin: '-1.1'
    ymax: '1.1'
    xmin: '-1.1'
    xmax: '1.1'
    tr_tag: ''''''
    legend: 'False'
    label1: '''coherence * exp(j phase)'''
    alpha1: '0.8'
    gui_hint: 5,2,6,5
    comment: |-
      A polar meter: angle is phase, radius is
      coherence. The rim is coherence 1.
  states: {}
- name: phase_time
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: '''Phase over time'''
    ylabel: '''phase'''
    yunit: '''degrees'''
    size: '1024'
    srate: samp_rate / chunk
    grid: 'True'
    ymin: '-180'
    ymax: '180'
    entags: 'False'
    tr_tag: ''''''
    legend: 'False'
    label1: '''phase'''
    color1: '"blue"'
    gui_hint: 5,7,6,5
    comment: |-
      A coherent pair holds still here. Two
      independent radios would not.
  states: {}
- name: phase_num
  id: qtgui_number_sink
  parameters:
    name: '''Phase RX1 - RX2'''
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    nconnections: '2'
    min: '-180'
    max: '180'
    label1: '''zeroed'''
    unit1: '''deg'''
    color1: '''black'''
    label2: '''raw'''
    unit2: '''deg'''
    color2: '''black'''
    gui_hint: 8,0,1,2
    comment: |-
      Zeroed AND raw, so zeroing can never hide
      what the board is doing.
  states: {}
- name: coh_num
  id: qtgui_number_sink
  parameters:
    name: '''Coherence - read this first'''
    type: float
    graph_type: qtgui.NUM_GRAPH_HORIZ
    min: '0'
    label1: '''|correlation|'''
    unit1: ''''''
    color1: '''black'''
    gui_hint: 9,0,1,2
    comment: Read this BEFORE the angle.
  states: {}

connections:
- [rx, '0', sel1, '0']
- [rx, '1', sel2, '0']
- [rx, '0', spectrum, '0']
- [rx, '1', spectrum, '1']
- [sel1, '0', phase, '0']
- [sel2, '0', phase, '1']
- [phase, '0', phase_num, '0']
- [phase, '2', phase_num, '1']
- [phase, '0', phase_time, '0']
- [phase, '1', coh_num, '0']
- [phase, '3', dial, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
